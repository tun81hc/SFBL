# Keil uVision project Project.uvproj, settings and files
target STM32L073Z_EVAL (ARM-ADS)
  device: STMicroelectronics
  output: STM32L073Z_EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32L073xx,USE_STM32L073Z_EVAL,USE_HAL_DRIVER,
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L0xx\Include;..\..\..\..\..\..\Drivers\STM32L0xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32L073Z_EVAL;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Drivers\BSP\Components\mfxstm32l152;
  library: MicroLIB
  link misc: --diag_suppress=L6329
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32L073Z_EVAL
    ../../../../../../Drivers/BSP/STM32L073Z_EVAL/: stm32l073z_eval.c stm32l073z_eval_io.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_crc.c stm32l0xx_hal_crc_ex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c
  group Example/MDK-ARM
    ./: startup_stm32l073xx.s
  group Example/User
    ../Src/: common.c flash_if.c main.c menu.c stm32l0xx_it.c ymodem.c
